# Keil uVision project briefcase.uvprojx, settings and files
target NXP LPC4088 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: semaphore
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: TARGET_LPC4088, TARGET_M4, TARGET_CORTEX_M, TARGET_NXP, TARGET_LPC408X, TOOLCHAIN_ARM_STD, TOOLCHAIN_ARM, __CORTEX_M4, ARM_MATH_CM4, __FPU_PRESENT=1, __MBED__=1, __ASSERT_MSG
  c include: ..\uCOS-II\Source;..\uCOS-II\Ports\ARM-Cortex-M4\Generic\ARM;..\mbed_nxp_lpc408x\api;..\mbed_nxp_lpc408x\common;..\mbed_nxp_lpc408x\hal;..\mbed_nxp_lpc408x\targets\cmsis;..\mbed_nxp_lpc408x\targets\cmsis\TARGET_NXP\TARGET_LPC408X;..\mbed_nxp_lpc408x\targets\cmsis\TARGET_NXP\TARGET_LPC408X\TOOLCHAIN_ARM_STD;..\mbed_nxp_lpc408x\targets\hal\TARGET_NXP\TARGET_LPC408X;..\mbed_nxp_lpc408x\targets\hal\TARGET_NXP\TARGET_LPC408X\TARGET_LPC4088;..\ebb;..\ebb\EALib;..\ebb\EALib\FATFileSystem;..\ebb\EALib\FATFileSystem\ChaN;..\ebb\I2S;..\ebb\LM75B;..\ebb\SDFileSystem
  asm define: CORE_M4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\mbed_nxp_lpc408x\targets\cmsis\TARGET_NXP\TARGET_LPC408X\TOOLCHAIN_ARM_STD\LPC407X_8X.sct
  link misc: ../mbed_nxp_lpc408x/Objects/mbed.lib ../ebb/Objects/ebb.lib ../uCOS-II/Objects/uCOS-II.lib  --any_placement=first_fit;
  group src
    ./src/: main.cpp buffer.cpp buffer.h timer.h timer.c
  group sys
    ../mbed_nxp_lpc408x/targets/cmsis/TARGET_NXP/TARGET_LPC408X/: cmsis_nvic.c system_LPC407x_8x_177x_8x.c
    ../mbed_nxp_lpc408x/targets/cmsis/TARGET_NXP/TARGET_LPC408X/TOOLCHAIN_ARM_STD/: startup_LPC407x_8x_177x_8x.S sys.cpp sys_helper.cpp
